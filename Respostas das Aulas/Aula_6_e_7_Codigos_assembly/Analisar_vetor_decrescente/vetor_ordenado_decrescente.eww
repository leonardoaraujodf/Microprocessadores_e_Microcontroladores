<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\vetor_ordenado_decrescente.ewp</path>
    </project>
    <batchBuild />
</workspace>
