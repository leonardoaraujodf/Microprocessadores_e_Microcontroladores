<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\produto_vetorial_int.ewp</path>
    </project>
    <batchBuild />
</workspace>
