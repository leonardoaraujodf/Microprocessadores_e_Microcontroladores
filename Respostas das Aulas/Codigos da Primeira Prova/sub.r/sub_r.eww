<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sub_r.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\subr_2\subr_2.ewp</path>
    </project>
    <batchBuild />
</workspace>
