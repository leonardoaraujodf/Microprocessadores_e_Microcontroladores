<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\motor_direction_iar_interrupcao.ewp</path>
  </project>
  <batchBuild/>
</workspace>


