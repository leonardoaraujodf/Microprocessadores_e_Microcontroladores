<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\controle_direcao_motor.ewp</path>
    </project>
    <batchBuild />
</workspace>
